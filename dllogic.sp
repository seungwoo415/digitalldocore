$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
.INCLUDE "/home/ff/eecs251b/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
*.BUSDELIMITER [

.SUBCKT DigitalLDOLogic clk rst comp_in out[9] out[8] out[7] out[6] out[5]
+ out[4] out[3] out[2] out[1] out[0]
Xpass_reg[8] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_20 Q=pass[8] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xg151__2398 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[9] A2=n_17 B1=pass[7]
+ B2=comp_in C1=rst X=n_20 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[3] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_12 Q=pass[3] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[4] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_13 Q=pass[4] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[5] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_16 Q=pass[5] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[6] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_15 Q=pass[6] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[1] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_18 Q=pass[1] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[2] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_11 Q=pass[2] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[7] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_14 Q=pass[7] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xg159 sky130_fd_sc_hd__buf_8 $PINS A=pass[9] X=out[9] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg160__5107 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[2] A2=n_17 B1=pass[0]
+ B2=comp_in C1=rst X=n_18 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg166__6260 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[6] A2=n_17 B1=pass[4]
+ B2=comp_in C1=rst X=n_16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg165__4319 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[7] A2=n_17 B1=pass[5]
+ B2=comp_in C1=rst X=n_15 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg167__8428 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[8] A2=n_17 B1=pass[6]
+ B2=comp_in C1=rst X=n_14 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg161__5526 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[5] A2=n_17 B1=pass[3]
+ B2=comp_in C1=rst X=n_13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg168__6783 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[4] A2=n_17 B1=pass[2]
+ B2=comp_in C1=rst X=n_12 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg164__3680 sky130_fd_sc_hd__a221o_1 $PINS A1=pass[3] A2=n_17 B1=pass[1]
+ B2=comp_in C1=rst X=n_11 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[9] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_10 Q=pass[9] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xpass_reg[0] sky130_fd_sc_hd__dfxtp_1 $PINS CLK=clk D=n_9 Q=pass[0] VGND=VSS
+ VNB=VSS VPB=VDD VPWR=VDD
Xg169__1617 sky130_fd_sc_hd__a21o_1 $PINS A1=pass[8] A2=comp_in B1=rst X=n_10
+ VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg170__2802 sky130_fd_sc_hd__or3_1 $PINS A=comp_in B=rst C=pass[1] X=n_9
+ VGND=VSS VNB=VSS VPB=VDD VPWR=VDD
Xg175 sky130_fd_sc_hd__buf_8 $PINS A=pass[3] X=out[3] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg178 sky130_fd_sc_hd__buf_8 $PINS A=pass[1] X=out[1] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg179 sky130_fd_sc_hd__buf_8 $PINS A=pass[8] X=out[8] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg171 sky130_fd_sc_hd__buf_8 $PINS A=pass[0] X=out[0] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg173 sky130_fd_sc_hd__buf_8 $PINS A=pass[5] X=out[5] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg176 sky130_fd_sc_hd__buf_8 $PINS A=pass[7] X=out[7] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg177 sky130_fd_sc_hd__buf_8 $PINS A=pass[2] X=out[2] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg174 sky130_fd_sc_hd__buf_8 $PINS A=pass[6] X=out[6] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg172 sky130_fd_sc_hd__buf_8 $PINS A=pass[4] X=out[4] VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
Xg180 sky130_fd_sc_hd__inv_1 $PINS A=comp_in Y=n_17 VGND=VSS VNB=VSS VPB=VDD
+ VPWR=VDD
.ENDS
