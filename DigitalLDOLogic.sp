$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
*.INCLUDE "/home/ff/eecs251b/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
*.lib '/home/ff/eecs251b/sky130/sky130_cds/sky130_release_0.0.1/models/sky130.lib.spice' tt
.include "./sky130_fd_sc_hd.spice"

*.BUSDELIMITER [

.SUBCKT DigitalLDOLogic clk rst comp_in out[9] out[8] out[7] out[6] out[5]
+ out[4] out[3] out[2] out[1] out[0] VDD VSS
Xpass_reg[8] clk n_20 VSS VSS VDD VDD pass[8] sky130_fd_sc_hd__dfxtp_1
Xg151__2398 pass[9] n_17 pass[7] comp_in rst VSS VSS VDD VDD n_20 sky130_fd_sc_hd__a221o_1
Xpass_reg[3] clk n_12 VSS VSS VDD VDD pass[3] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[4] clk n_13 VSS VSS VDD VDD pass[4] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[5] clk n_16 VSS VSS VDD VDD pass[5] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[6] clk n_15 VSS VSS VDD VDD pass[6] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[1] clk n_18 VSS VSS VDD VDD pass[1] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[2] clk n_11 VSS VSS VDD VDD pass[2] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[7] clk n_14 VSS VSS VDD VDD pass[7] sky130_fd_sc_hd__dfxtp_1
Xg159 pass[9] VSS VSS VDD VDD out[9] sky130_fd_sc_hd__buf_8
Xg160__5107 pass[2] n_17 pass[0] comp_in rst VSS VSS VDD VDD n_18 sky130_fd_sc_hd__a221o_1
Xg166__6260 pass[6] n_17 pass[4] comp_in rst VSS VSS VDD VDD n_16 sky130_fd_sc_hd__a221o_1
Xg165__4319 pass[7] n_17 pass[5] comp_in rst VSS VSS VDD VDD n_15 sky130_fd_sc_hd__a221o_1
Xg167__8428 pass[8] n_17 pass[6] comp_in rst VSS VSS VDD VDD n_14 sky130_fd_sc_hd__a221o_1
Xg161__5526 pass[5] n_17 pass[3] comp_in rst VSS VSS VDD VDD n_13 sky130_fd_sc_hd__a221o_1
Xg168__6783 pass[4] n_17 pass[2] comp_in rst VSS VSS VDD VDD n_12 sky130_fd_sc_hd__a221o_1
Xg164__3680 pass[3] n_17 pass[1] comp_in rst VSS VSS VDD VDD n_11 sky130_fd_sc_hd__a221o_1
Xpass_reg[9] clk n_10 VSS VSS VDD VDD pass[9] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[0] clk n_9 VSS VSS VDD VDD pass[0] sky130_fd_sc_hd__dfxtp_1
Xg169__1617 pass[8] comp_in rst VSS VSS VDD VDD n_10 sky130_fd_sc_hd__a21o_1
Xg170__2802 comp_in rst pass[1] VSS VSS VDD VDD n_9 sky130_fd_sc_hd__or3_1
Xg175 pass[3] VSS VSS VDD VDD out[3] sky130_fd_sc_hd__buf_8
Xg178 pass[1] VSS VSS VDD VDD out[1] sky130_fd_sc_hd__buf_8
Xg179 pass[8] VSS VSS VDD VDD out[8] sky130_fd_sc_hd__buf_8
Xg171 pass[0] VSS VSS VDD VDD out[0] sky130_fd_sc_hd__buf_8
Xg173 pass[5] VSS VSS VDD VDD out[5] sky130_fd_sc_hd__buf_8
Xg176 pass[7] VSS VSS VDD VDD out[7] sky130_fd_sc_hd__buf_8
Xg177 pass[2] VSS VSS VDD VDD out[2] sky130_fd_sc_hd__buf_8
Xg174 pass[6] VSS VSS VDD VDD out[6] sky130_fd_sc_hd__buf_8
Xg172 pass[4] VSS VSS VDD VDD out[4] sky130_fd_sc_hd__buf_8
Xg180 comp_in VSS VSS VDD VDD n_17 sky130_fd_sc_hd__inv_1
.ENDS
